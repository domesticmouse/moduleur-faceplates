File: moduleur-vco/VCO/VCO.kicad_pcb (KiCad board)
At the start: 2 copper layers, 60.6 x 128.5 mm, 0 parts

Commit message: Multiple boards
Other:
- board size 60.6 x 128.5 mm -> 252.6 x 128.5 mm
